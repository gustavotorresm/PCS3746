## drivers/padrao/Kconfig
```kconfig
config DRIVER_PADRAO
tristate "Driver padrao" 
depends on ARM
default y if ARM
help
  driver padrao module
```
